## vendor/oplus/kernel/touchpanel/oplus_touchscreen/ilitek/Kconfig
```kconfig
source "drivers/input/touchscreen/oplus_touchscreen/ilitek/ilitek9881h_v4/Kconfig"
```
